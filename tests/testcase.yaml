## tests/testcase.yaml
```yaml
tests:
# section.subsection
  lib.control:
    # platform: board@revision
    platform_allow: nucleo_g474re native_posix
```
